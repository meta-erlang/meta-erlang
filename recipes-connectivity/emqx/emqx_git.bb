require emqx.inc

SRCREV = "45d40468c29e76b4f086354ab985cc85fa771c63"
PV = "3.2.0-git${SRCPV}"
PR = "r0"

REBAR3_PROFILE = "emqx"
REBAR3_RELEASE_NAME = "emqx-v3.2-beta.1-2-g45d4046"
