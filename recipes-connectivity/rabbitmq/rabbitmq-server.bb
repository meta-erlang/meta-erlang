require rabbitmq-server.inc

PV = "3.13.7"

SRC_URI[md5sum] = "33977a1c0e3b41cae05a23f3e6fab5f8"
SRC_URI[sha256sum] = "18353262e77085048bac55cedb55b77f0987dad97649317d812b99b1bdc6661d"