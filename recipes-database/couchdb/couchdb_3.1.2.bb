require ${PN}.inc

SRC_URI[md5sum] = "5f975ebe46e0b8ac8cdddb8e0f8cd49a"
SRC_URI[sha256sum] = "e799c489a9c8fa50c3c40b5267f526d80c93cb57fecafb77ee37f79606f4fb27"
