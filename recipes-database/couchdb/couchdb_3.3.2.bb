require ${PN}.inc

SRC_URI[md5sum] = "03ba7759a0553e97201637b106bf44f1"
SRC_URI[sha256sum] = "3d6823d42d10cf0d4f86c9c4fe59c9932c89d68578fcb6c4b4278dc769308daa"
