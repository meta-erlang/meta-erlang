require ${PN}.inc

SRC_URI[md5sum] = "c39523b147adefa2529bdcc061962f6a"
SRC_URI[sha256sum] = "69c9fd6f80133557f68a02e92dda72a4fd646d646f429f45bb8329a30f82f20e"
