require ${PN}.inc

SRC_URI[md5sum] = "88d179d439093d8ce3adcbc70592743c"
SRC_URI[sha256sum] = "8ffe766bba2ba39a7b49689a0732afacf69caffdf8e2d95447e82fb173c78ca3"
