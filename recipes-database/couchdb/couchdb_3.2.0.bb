require ${PN}.inc

SRC_URI[md5sum] = "5a7c3d81d4a2555d12bd45d3fb156bc2"
SRC_URI[sha256sum] = "8bea574faa6bb0926c670542d8318c322268cf7e6614dab318dea734ccf1b00c"
