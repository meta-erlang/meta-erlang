require ${PN}.inc

SRC_URI[md5sum] = "8c67643901e69fd52984f6bf25fc1a79"
SRC_URI[sha256sum] = "7a2007b5f673d4be22a25c9a111d9066919d872ddb9135a7dcec0122299bd39e"
