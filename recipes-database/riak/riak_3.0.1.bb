require ${PN}.inc

SRCREV = "dbd9d093a846e3231a7ddc16904998cbc22248f9"
