
inherit erlang

DEPENDS += "rebar-native"

B = "${S}"
