export HEX_HOME = "${UNPACKDIR}/hex"