inherit rebar3
export REBAR_BASE_DIR = "${S}/_build"
B ?= "${S}"
