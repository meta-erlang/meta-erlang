require ${PN}.inc

SRCREV = "0706178dea1c62d8d63c33c86bbf473dcaef89d5"

FILESEXTRAPATHS_prepend := "${THISDIR}/files/24:"