require ${PN}.inc

SRCREV = "fea47f1127b7190898b84852a90a4426fa022b39"

FILESEXTRAPATHS_prepend := "${THISDIR}/files/23:"