include erlang.inc
include erlang-${PV}.inc
require erlang-${PV}-manifest.inc

PR = "r1"