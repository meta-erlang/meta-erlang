include erlang.inc
include erlang-${PV}.inc
require erlang-${PV}-manifest.inc

PR = "r2"

FILESEXTRAPATHS_prepend := "${THISDIR}/files/22:"