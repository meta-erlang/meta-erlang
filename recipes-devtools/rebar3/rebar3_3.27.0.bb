require rebar3.inc

PR = "${INC_PR}.0"

SRCREV = "619df55d9dab109cbd1b5d9ed1d45c93f5450e24"
