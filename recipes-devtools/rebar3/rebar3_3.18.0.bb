require rebar3.inc

PR = "${INC_PR}.1"

SRCREV = "174fd9070195443d693d444ecd1f2b7aa91661fe"
