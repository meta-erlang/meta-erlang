require rebar3.inc

PR = "${INC_PR}.0"

SRCREV = "74c766d0d41117bc4b14987b8ada12aee5fe0b86"
