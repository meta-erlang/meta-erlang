require rebar3.inc

PR = "${INC_PR}.1"

SRCREV = "e008a2ff40f708494a7c259a1fd8c2e77f7cd6a0"
