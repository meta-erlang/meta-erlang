require rebar3.inc

SRC_URI[sha256sum] = "656b4a0bd75f340173e67a33c92e4d422b5ccf054f93ba35a9d780b545ee827e"