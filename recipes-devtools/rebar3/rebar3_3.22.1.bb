require rebar3.inc

PR = "${INC_PR}.0"

SRCREV = "26400cd5082bf44bec66227164074677d3bd237c"
