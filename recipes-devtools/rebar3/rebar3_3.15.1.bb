require rebar3.inc

PR = "${INC_PR}.1"

SRCREV = "e7f896aeedca2a5f1ceec60b7013d1535d49da40"
