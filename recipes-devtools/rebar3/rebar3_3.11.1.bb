require rebar3.inc

SRC_URI[sha256sum] = "a1822db5210b96b5f8ef10e433b22df19c5fc54dfd847bcaab86c65151ce4171"
