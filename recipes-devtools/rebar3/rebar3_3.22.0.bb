require rebar3.inc

PR = "${INC_PR}.0"

SRCREV = "0a432f2f60cd32b8ff07d644a506dba15eb6f04a"
