require rebar3.inc

SRCREV = "e33357af97605f8b2cfffab3e16fc1588165afa1"
