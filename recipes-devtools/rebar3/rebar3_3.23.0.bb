require rebar3.inc

PR = "${INC_PR}.0"

SRCREV = "bde4b54248d16280b2c70a244aca3bb7566e2033"
