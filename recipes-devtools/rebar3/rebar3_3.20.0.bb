require rebar3.inc

PR = "${INC_PR}.1"

SRCREV = "3f563feaf1091a1980241adefa83a32dd2eebf7c"
