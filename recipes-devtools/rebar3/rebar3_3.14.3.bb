require rebar3.inc

SRCREV = "6036581295a6741612dea9eed5277affc5da21d1"
