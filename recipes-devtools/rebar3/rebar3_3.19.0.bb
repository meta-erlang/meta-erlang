require rebar3.inc

PR = "${INC_PR}.1"

SRCREV = "cc1b22283656282d3518c176dd419eaa6cfce548"
