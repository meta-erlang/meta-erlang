require rebar3.inc

SRC_URI[sha256sum] = "b7330a67a8cb5d6fb3b53a3246208b7c2b248546bcf62ef71a9a27b1d541c2d8"