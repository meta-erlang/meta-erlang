require rebar3.inc

PR = "${INC_PR}.0"

SRCREV = "6243d3fb017c9759ba699850e8a6b57700fbfabd"
