require rebar3.inc

PR = "${INC_PR}.1"

SRCREV = "2d443b5c8b9fe5f1beb8027e9c2ca7e5dcc61810"

SRC_URI += "file://0001-Do-not-discard-parameters-system_libs-and-include-er.patch"
