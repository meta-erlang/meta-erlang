include elixir.inc

SRCREV = "1145dc01680aab7094f8a6dbd38b65185e14adb4"
SRC_URI = "git://github.com/elixir-lang/elixir;branch=v1.10"

PR = "r0"
