include elixir.inc

SRCREV = "7e4fbe657dbf9c3e19e3d2bd6c17cc6d724b4710"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.13;protocol=https"

PR = "r0"
