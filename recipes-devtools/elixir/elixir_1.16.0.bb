include elixir.inc

SRCREV = "38ddc98fef7faf6f4666703dcd9c99105e6388d2"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.16;protocol=https"

PR = "r0"
