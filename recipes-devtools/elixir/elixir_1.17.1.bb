include elixir.inc

SRCREV = "6bfb95ab884f11475de6da3f99c6528938e025a8"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.17;protocol=https"

PR = "r0"
