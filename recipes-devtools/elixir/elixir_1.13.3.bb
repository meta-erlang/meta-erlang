include elixir.inc

SRCREV = "b63f8f541e9d8951dbbcb39a8551bd74a3fe9a59"
SRC_URI = "git://github.com/elixir-lang/elixir;branch=v1.13;protocol=https"

PR = "r0"
