include elixir.inc

SRCREV ?= "759443e724f55bf58e71c0603644e99058918d52"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.20;protocol=https"

PR = "r0"
