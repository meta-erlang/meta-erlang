include elixir.inc

SRCREV = "79388035f5391f0a283a48fba792ae3b4f4b5f21"
SRC_URI = "git://github.com/elixir-lang/elixir;branch=v1.9"

PR = "r0"
