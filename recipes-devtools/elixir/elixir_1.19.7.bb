include elixir.inc

SRCREV ?= "f1657a626c683a9ea416c1f63f449022c486a09c"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.19;protocol=https"

PR = "r0"
