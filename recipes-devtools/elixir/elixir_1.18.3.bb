include elixir.inc

SRCREV ?= "e35ffc5a903bff3b595e323eb1ac12c4ecd515ad"
PV = "1.18.3"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.18;protocol=https"

PR = "r0"
