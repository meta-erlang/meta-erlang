include elixir.inc

SRCREV ?= "7b20c281d521aa7aa2ad2baa1e9ae6c579d79d0c"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.18;protocol=https"

PR = "r0"
