include elixir.inc

SRCREV = "0909940b04a3e22c9ea4fedafa2aac349717011c"
SRC_URI = "git://github.com/elixir-lang/elixir;branch=v1.14;protocol=https"

PR = "r0"
