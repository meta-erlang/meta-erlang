include elixir.inc

SRCREV ?= "4a28692668bef879029291b7ff329a84a1f933bb"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.20;protocol=https"

PR = "r0"
