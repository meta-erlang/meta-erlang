include elixir.inc

SRCREV = "c5151e6890b5ac8df13276459696f0f47a8e634b"
SRC_URI = "git://github.com/elixir-lang/elixir;branch=v1.14;protocol=https"

PR = "r0"
