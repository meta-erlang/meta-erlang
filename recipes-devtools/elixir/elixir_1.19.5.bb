include elixir.inc

SRCREV ?= "d33fd8e413fe98e0e54dde7ef94fadb272b1ef67"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.19;protocol=https"

PR = "r0"
