include elixir.inc

SRCREV = "42807d288e086a12c4309a254f19cb1de779c8ce"
SRC_URI = "git://github.com/elixir-lang/elixir;branch=v1.12"

PR = "r0"
