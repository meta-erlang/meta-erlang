include elixir.inc

SRCREV = "29fdd09c0fcb5f029d43591665de35491f7378dd"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.15;protocol=https"

PR = "r0"
