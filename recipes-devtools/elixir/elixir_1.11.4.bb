include elixir.inc

SRCREV = "308255bda81e7f76f9bec838cef033e8e869981b"
SRC_URI = "git://github.com/elixir-lang/elixir;branch=v1.11"

PR = "r0"
