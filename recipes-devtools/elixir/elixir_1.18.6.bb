include elixir.inc

SRCREV ?= "2243c949dc3da804f8e3c8d9af6ec603854919bd"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.18;protocol=https"

PR = "r0"
