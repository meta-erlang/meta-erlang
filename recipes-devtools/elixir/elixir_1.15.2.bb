include elixir.inc

SRCREV = "7f7a8bca99fa306a41a985df0018ba642e577d4d"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.15;protocol=https"

PR = "r0"
