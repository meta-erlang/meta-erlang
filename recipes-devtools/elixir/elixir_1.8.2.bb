include elixir.inc

SRCREV = "98485daab0a9f3ac2d7809d38f5e57cd73cb22ac"
SRC_URI = "git://github.com/elixir-lang/elixir;branch=v1.8"

PR = "r0"
