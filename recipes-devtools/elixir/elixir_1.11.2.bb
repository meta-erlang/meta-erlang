include elixir.inc

SRCREV = "7533e56c1baec77c2aa1a4c0ad02730fae464201"
SRC_URI = "git://github.com/elixir-lang/elixir;branch=v1.11"

PR = "r0"
