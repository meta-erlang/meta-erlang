include elixir.inc

SRCREV = "6730d669fb319411f8e411d4126f1f4067ef9231"
SRC_URI = "git://github.com/elixir-lang/elixir;branch=v1.14;protocol=https"

PR = "r0"
