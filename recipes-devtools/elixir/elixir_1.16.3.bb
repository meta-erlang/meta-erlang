include elixir.inc

SRCREV = "327063cc8485692f2b902553fb599a2bef5a0f8f"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.16;protocol=https"

PR = "r0"
