include elixir.inc

SRCREV = "5bd7a90864417e7be9483002cfa0e543d265b71d"
SRC_URI = "git://github.com/elixir-lang/elixir;branch=v1.10"

PR = "r0"
