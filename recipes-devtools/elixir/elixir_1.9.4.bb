include elixir.inc

SRCREV = "055526057ac9992cc1df87441357c4e56d45235d"
SRC_URI = "git://github.com/elixir-lang/elixir;branch=v1.9"

PR = "r0"
