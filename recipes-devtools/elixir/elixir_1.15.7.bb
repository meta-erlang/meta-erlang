include elixir.inc

SRCREV = "927b10df80ee1c1c7396e68efe00d06bc3e80420"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.15;protocol=https"

PR = "r0"
