include elixir.inc

SRCREV = "6f96693b355a9b670f2630fd8e6217b69e325c5a"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.14;protocol=https"

PR = "r0"
