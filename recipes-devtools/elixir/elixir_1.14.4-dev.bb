include elixir.inc

SRCREV = "73d58ec01bf7b7392647ab2bdcf7fda2bde0c096"
SRC_URI += "git://github.com/elixir-lang/elixir;branch=v1.14;protocol=https"

PR = "r0"
