BBCLASSEXTEND += "nativesdk native"
